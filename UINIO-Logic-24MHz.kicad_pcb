# Repository vanbwodonk/CY7C68013A-logic-analyzer

## KiCad design UINIO-Logic-24MHz.kicad_pcb

Parts:
C1, C2, C10: 1uF; C_0603_1608Metric
C3, C4, C5, C6, C7, C11: 0.1uF; C_0603_1608Metric
C8, C9: 12pF; C_0603_1608Metric
D1: LED Red; LED_0805_2012Metric
D2: LED Yellow; LED_0805_2012Metric
D3: LED Green; LED_0805_2012Metric
D5, D6: LESD5D5.0CT1G; D_SOD-523
J1: Conn_01x10_Pin; IDC-Header_2x05_P2.54mm_EdgeMount
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8: SolderJumper-2_Open_RoundedPad_small
JP9, JP10: SolderJumper-2_Bridged2Bar_RoundedPad_small
R1, R2, R3, R4, R5, R6, R7, R8: 100R; R_0603_1608Metric
R9, R10, R11, R12, R13, R14, R15, R16, R23: 100K; R_0603_1608Metric
R17: 1K; R_0603_1608Metric
R18, R19, R20: 10K; R_0603_1608Metric
R21, R22: 2.2K; R_0603_1608Metric
R24, R25: 5.1K; R_0603_1608Metric
U1: AT24CS64-XHM; SO-8_3.9x4.9mm_P1.27mm
U2: 74HC245C; TSSOP-20_L6.5-W4.4-P0.65-LS6.4-BL
U3: AP2127N-3.3; SOT-23
U4: CY7C68013A-56LTX; QFN-56-1EP_8x8mm_P0.5mm_EP4.5x5.2mm_ThermalVias
USB1: USB_Type_C_16Pin; USB-C-SMD_TYPEC-304J-BCP16
Y2: Crystal; Crystal_HC49-4H_Vertical

Connections:
+3.3V: C2.2, C3.1, C4.1, C5.1, C6.1, C7.1, C11.1, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R20.2, R21.1, R22.1, R23.2, U1.8 (VCC), U2.20 (VCC), U3.2 (VO), U4.3 (AVCC), U4.7 (AVCC), U4.11 (VCC), U4.17 (VCC), U4.27 (VCC), U4.32 (VCC), U4.43 (VCC), U4.55 (VCC)
+5V: C1.2, U3.3 (VI), USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
/CLK: J1.9, U4.54 (CLKOUT)
/I2C_SCL: JP10.2 (B), U4.15 (SCL)
/I2C_SDA: JP9.2 (B), U4.16 (SDA)
/INPUT1: JP1.2 (B), R1.2, R9.1, U2.18 (B1)
/INPUT2: JP2.2 (B), R2.2, R10.1, U2.17 (B2)
/INPUT3: JP3.2 (B), R3.2, R11.1, U2.16 (B3)
/INPUT4: JP4.2 (B), R4.2, R12.1, U2.15 (B4)
/INPUT5: JP5.2 (B), R5.2, R13.1, U2.14 (B5)
/INPUT6: JP6.2 (B), R6.2, R14.1, U2.13 (B6)
/INPUT7: JP7.2 (B), R7.2, R15.1, U2.12 (B7)
/INPUT8: JP8.2 (B), R8.2, R16.1, U2.11 (B8)
/PB0: JP1.1 (A), U2.2 (A1), U4.18 (PB0/FD0)
/PB1: JP2.1 (A), U2.3 (A2), U4.19 (PB1/FD1)
/PB2: JP3.1 (A), U2.4 (A3), U4.20 (PB2/FD2)
/PB3: JP4.1 (A), U2.5 (A4), U4.21 (PB3/FD3)
/PB4: JP5.1 (A), U2.6 (A5), U4.22 (PB4/FD4)
/PB5: JP6.1 (A), U2.7 (A6), U4.23 (PB5/FD5)
/PB6: JP7.1 (A), U2.8 (A7), U4.24 (PB6/FD6)
/PB7: JP8.1 (A), U2.9 (A8), U4.25 (PB7/FD7)
/USB_Data+: D6.2 (A2), U4.8 (D+), USB1.A6 (DP1), USB1.B6 (DP2)
/USB_Data-: D5.2 (A2), U4.9 (D-), USB1.A7 (DN1), USB1.B7 (DN2)
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.1, C11.2, D1.1 (K), D2.1 (K), D3.1 (K), D5.1 (A1), D6.1 (A1), J1.10, R24.2, R25.2, U1.1 (A0), U1.2 (A1), U1.3 (A2), U1.4 (GND), U1.7 (WP), U2.1 (DIR), U2.10 (GND), U2.19 (/OE), U3.1 (GND), U4.6 (AGND), U4.10 (AGND), U4.12 (GND), U4.14 (RESERVED), U4.26 (GND), U4.28 (GND), U4.41 (GND), U4.53 (GND), U4.56 (GND), U4.57 (EP), USB1.13 (GND), USB1.14 (GND), USB1.15 (GND), USB1.16 (GND), USB1.A1B12 (GND), USB1.B1A12 (GND)
unnamed: D1.2 (A), R17.1
unnamed: D2.2 (A), R18.1
unnamed: D3.2 (A), R19.1
unnamed: J1.1, R1.1
unnamed: J1.2, R2.1
unnamed: J1.3, R3.1
unnamed: J1.4, R4.1
unnamed: J1.5, R5.1
unnamed: J1.6, R6.1
unnamed: J1.7, R7.1
unnamed: J1.8, R8.1
unnamed: JP9.1 (A), R22.2, U1.5 (SDA)
unnamed: JP10.1 (A), R21.2, U1.6 (SCL)
unnamed: R18.2, U4.33 (PA0/~INT0)
unnamed: R19.2, U4.34 (PA1/~INT1)
unnamed: R20.1, U4.44 (WAKEUP)
unnamed: C9.2, U4.5 (XTALIN), Y2.1
unnamed: C8.2, U4.4 (XTALOUT), Y2.2
unnamed: C10.2, R23.1, U4.42 (~RESET)
unnamed: R24.1, USB1.A5 (CC1)
unnamed: R25.1, USB1.B5 (CC2)

Notes on the sheet:
CY7C68013A USB2.0 控制器
LDO
上拉电阻
USB Type-C
EEPROM

Board: 2 copper layers, 43.4 x 25.4 mm, 58 parts (2 on the bottom side), 45 nets.

## Commit log

2026-04-06 update hardware
2026-04-08 update sch & brd with saleae clone hardware
2026-04-08 fix some routing
2026-04-13 update routing
2026-04-20 fix routing
